# Keil uVision project I2C_Master_Dualaddr.uvprojx, settings and files
target N32L40x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L406MB Nationstech
  pack: Nationstech.N32L40x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: I2C_Master_Dualaddr_Project +hex
  AfterMake: fromelf --bin --output=.\bin\I2C_Master_Dualaddr_Project.bin .\Objects\I2C_Master_Dualaddr_Project.axf
  AfterMake: fromelf --vhx -d --32x1 .\Objects\I2C_Master_Dualaddr_Project.axf --output=.\bin\I2C_Master_Dualaddr_Project.dua
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT=1
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\n32l40x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group FWLB
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_flash.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_rcc.c n32l40x_usart.c
  group USER
    ../src/: main.c n32l40x_it.c
  group LOG
    ../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
