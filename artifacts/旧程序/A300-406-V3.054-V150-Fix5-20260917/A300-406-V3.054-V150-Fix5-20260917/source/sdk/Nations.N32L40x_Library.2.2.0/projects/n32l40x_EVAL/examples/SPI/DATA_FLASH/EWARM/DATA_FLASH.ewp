# IAR project DATA_FLASH.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32L406RD Nations N32L406RD
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32L40X; USE_STDPERIPH_DRIVER; N32L406RDL7
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\..\..\..\bsp; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32l40x_std_periph_driver\inc; ..\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DATA_FLASH.bin
  ILINK.IlinkOutputFile: SPI_FLASH.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: n32l40x_crc.c n32l40x_gpio.c n32l40x_rcc.c n32l40x_spi.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x_EWARM.s
  group USER
    ../src/: main.c n32l40x_it.c spi_flash.c
