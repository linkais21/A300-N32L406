# Keil uVision project Mass_Stroage_DataFlash.uvprojx, settings and files
target N32L40x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L406MB Nationstech
  pack: Nationstech.N32L40x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Mass_Stroage_DataFlash +hex
  AfterMake: fromelf --bin --output=.\bin\Mass_Stroage_DataFlash.bin .\Objects\Mass_Stroage_DataFlash.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT=1,SYSCLK_SRC=SYSCLK_USE_HSE_PLL,SYSCLK_FREQ=48000000
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32l40x_std_periph_driver\inc;..\..\..\..\..\..\firmware\n32l40x_usbfs_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group FWLB
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_dma.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_rcc.c n32l40x_usart.c n32l40x_pwr.c
  group USER
    ../src/: main.c n32l40x_it.c hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_bot.c usb_scsi.c mass_mal.c scsi_data.c memory.c
  group DOC
    ../: readme.txt
  group n32l40x_usbfs_driver
    ../../../../../../firmware/n32l40x_usbfs_driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
