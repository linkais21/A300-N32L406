# Keil uVision project LP_RUN.uvprojx, settings and files
target N32L40x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L406MB Nationstech
  pack: Nationstech.N32L40x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LP_RUN +hex
  AfterMake: fromelf --bin --output=.\bin\LP_RUN.bin .\Objects\LP_RUN.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32l40x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group USER
    ../src/: main.c User_Sysclock_Config.c User_LED_Config.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: n32l40x_rcc.c misc.c n32l40x_exti.c n32l40x_gpio.c n32l40x_pwr.c n32l40x_flash.c n32l40x_dbg.c n32l40x_usart.c
  group LOG
    ../../../../bsp/src/: log.c
